# Keil uVision project Project.uvprojx, settings and files
target PY32F003F18P6TU (6220000::V6.22::ARMCLANG)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F003F18P6TU +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F003x8,USE_FULL_LL_DRIVER
  c misc: -Wno-unused-parameter -Wno-unused-function -Wno-unused-variable
  c include: ..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f003x8.s
    ../Core/Src/: system_py32f0xx.c
  group Application/User
    ../Core/Src/: main.c app_ui.c bsp_flash.c theme.c py32f0xx_hal_msp.c py32f0xx_it.c global.c function.c bsp_gpio.c bsp_spi.c bsp_i2c.c bsp_adc.c bsp_tim.c st7735.c INA226.c Font_asc.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_rcc.c py32f0xx_hal_gpio.c py32f0xx_hal_pwr.c py32f0xx_hal_cortex.c py32f0xx_hal_i2c.c py32f0xx_hal_adc.c py32f0xx_hal_dma.c py32f0xx_hal_flash.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_ll_spi.c py32f0xx_ll_gpio.c
  group Doc
    ../: README.md
