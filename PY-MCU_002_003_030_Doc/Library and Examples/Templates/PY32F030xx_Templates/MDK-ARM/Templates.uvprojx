# Keil uVision project Templates.uvprojx, settings and files
target PY32F030x3_Templates (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x3 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x7_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x3
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Inc;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Common
    ./: startup_py32f030xx.s
    ../Src/: system_py32f0xx.c
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_cortex.c py32f0xx_hal_dma.c py32f0xx_hal_gpio.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_pwr.c
  group Doc
    ../: readme.txt
target PY32F030x4_Templates (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x4 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x7_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
target PY32F030x6_Templates (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x6 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x7_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x6
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target PY32F030x7_Templates (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x7 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x0000C000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x7_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x7
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x1800
target PY32F030x8_Templates (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x7_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.2.0
