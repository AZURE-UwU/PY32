# Keil uVision project ADC_MultiChannelSingleConersion_AWD.uvprojx, settings and files
target ADC_MultiChannelSingleConersion_AWD_Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: ADC_MultiChannelSingleConersion_AWD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F030xx_Start_Kit;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f030xx.s
    ../Src/: system_py32f0xx.c
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
  group BSP/py32f030xx_Start_Kit
    ../../../../../../drivers/BSP/PY32F030xx_Start_Kit/: py32f030xx_Start_Kit.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c
    ../../../../../../drivers/PY32F0xx_HAL_Driver/src/: py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_dma.c py32f0xx_hal_pwr.c py32f0xx_hal_uart.c py32f0xx_hal_cortex.c
  group Doc
    ../: readme.txt
target ADC_MultiChannelSingleConersion_AWD_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.0.3
  cpu: as above
  output: ADC_MultiChannelSingleConersion_AWD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F030xx_Start_Kit;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.2.0
