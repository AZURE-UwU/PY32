# IAR project Project.ewp, settings and files
configuration PY32F003x8_Templates (ARM, debug)
  General.OGChipSelectEditMenu: PY32F003x8 Puya PY32F003x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: PY32F003x8
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f003x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PY32F003x6_Templates (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F003x6 Puya PY32F003x6
  ICCARM.CCDefines: PY32F003x6
  ILINK.IlinkIcfFile: py32f003x6_flash.icf
configuration PY32F003x4_Templates (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F003x4 Puya PY32F003x4
  ICCARM.CCDefines: PY32F003x4
  ILINK.IlinkIcfFile: py32f003x4_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_py32f0xx.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_utils.c
  group Example/EWARM
    ./: startup_py32f003xx.s
  group Example/User
    ../Src/: main.c py32f0xx_it.c
