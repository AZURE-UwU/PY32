# IAR project Project.ewp, settings and files
configuration PY32F002-STK (ARM, debug)
  General.OGChipSelectEditMenu: PY32F002Ax5 Puya PY32F002Ax5
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F002Ax5
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F002xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f002ax5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32F002xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F002xx_Start_Kit/: py32f002xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f0xx.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../../../../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_cortex.c py32f0xx_hal_gpio.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c
  group Example/EWARM
    ./: startup_py32f002xx.s
  group Example/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
